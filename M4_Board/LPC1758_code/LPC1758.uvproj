# Keil uVision project LPC1758.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1758 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: LPC1758 +hex
  c flags: Optim=1 uC99=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: startup_LPC17xx.s UART2.c Main.c gpio.c command_processor.h command_processor.c pinsel.h
    ../../Downloads/: system_LPC17xx 2 1.c
